# Keil uVision project ad19.uvprojx, settings and files
target ad19 (6160000::V6.16::ARMCLANG)
  device: STM32U575RGTx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.3.2.0
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x80FFFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: ad19 +hex
  AfterMake: hex2bin.bat ad19 ad19
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx,LEPTON_25
  c misc: -Wno-invalid-source-encoding
  c include: ../Core/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../Drivers/CMSIS/Include;..\Lepton\INC;..\Lepton\CONTROL\V3_5;..\Hardware;..\Utilities;..\Middlewares\ST\usbx\common\core\inc;..\Middlewares\ST\usbx\common\usbx_device_classes\inc;..\Middlewares\ST\usbx\common\usbx_stm32_device_controllers;..\Middlewares\ST\usbx\ports\generic\inc;..\USBX\Target;..\USBX\App;..\Middlewares\ff11\src
  library: MicroLIB
  memory RVCT4: ROM 0x803c000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/User/Core
    ../Core/Src/: main.c photo_album.c icache.c memorymap.c stm32u5xx_it.c stm32u5xx_hal_msp.c
    ./: startup_stm32u575xx.s
    ../Core/Inc/: stm32u5xx_hal_conf.h stm32u5xx_it.h
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal_dcmi.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_ll_usb.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_wwdg.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Application/LeptonSDK
    ../Lepton/SRC/: LEPTON_AGC.c LEPTON_CFG.c LEPTON_I2C_Protocol.c LEPTON_I2C_Service.c LEPTON_OEM.c LEPTON_RAD.c LEPTON_SDK.c LEPTON_SYS.c LEPTON_VID.c crc16fast.c
  group Application/LeptonAPP
    ../Lepton/CONTROL/V3_5/: Lepton_Common_Data.c Lepton_Stm32_Control.c Lepton_Stm32_I2C.c Lepton_Stm32_SPI_DMA.c Lepton_Delay.c
  group hardware
    ../Hardware/: bsp.c bsp.h i2c_cst816t.c i2c_cst816t.h st7789.c st7789.h st7789_def.h battery.c bsp_ov2640.h bsp_ov2640.c bsp_i2c.h bsp_i2c.c spi_flash.c spi_flash.h spi_flash_defs.h bsp_gc2145.c key.c key.h bsp_flash.c
  group utilities
    ../Utilities/fonts/: fonts.c fonts.h
    ../Utilities/images/: colormap.h colormap_rgb565_msb.c COLOUR_ARCTIC.c COLOUR_BLACKHOT.c COLOUR_COLOUR1.c COLOUR_COLOUR2.c COLOUR_FUSION.c COLOUR_IRONBOW2.c COLOUR_RAINBOW.c images.c images.h icon_spot_center.c icon_battery100.c icon_logo_dark.c icon_spot_hot.c icon_spot_cold.c icon_info_saving.c icon_save_failed.c icon_save_select.c icon_save_success.c icon_info_delete.c icon_save_delete.c icon_battery0.c icon_battery30.c icon_battery60.c icon_charging.c icon_logo_dark_anx.c icon_logo_dark_laureii.c icon_logo_default.c icon_logo_anx_ad19fs.c icon_logo_anx_ad19u.c icon_logo_laureii_ad19u.c icon_logo_default_ad19u.c
  group fatfs
    ../Middlewares/ff11/src/: ff.c ff.h sd_diskio.h sd_diskio.c ffconf.h diskio.h ffunicode.c
target ad19_35 (6160000::V6.16::ARMCLANG)
  device: STM32U575RGTx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.3.2.0
  cpu: as above
  output: ad19 +hex
  AfterMake: C:\Users\EVA\Desktop\AD19\ad19\MDK-ARM\hex2bin.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx,UX_INCLUDE_USER_DEFINE_FILE
  c misc: -Wno-invalid-source-encoding
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x803c000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xc0000
target ad19_30 (6160000::V6.16::ARMCLANG)
  device: STM32U575RGTx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.3.2.0
  cpu: as above
  output: ad19 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx,UX_INCLUDE_USER_DEFINE_FILE,LEPTON_30
  c misc: -Wno-invalid-source-encoding
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x803c000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xc0000
target ad19_fs (6160000::V6.16::ARMCLANG)
  device: STM32U575RGTx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.3.2.0
  cpu: as above
  output: ad19 +hex
  AfterMake: D:\0project\ad19\code\MDK-ARM\hex2bin.bat ad19 ad19
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx,UX_INCLUDE_USER_DEFINE_FILE,LEPTON_FS
  c misc: -Wno-invalid-source-encoding
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x803c000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xc0000
software components: CMSIS:CORE 4.3.0
