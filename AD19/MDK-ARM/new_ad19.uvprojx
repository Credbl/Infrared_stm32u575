# Keil uVision project new_ad19.uvprojx, settings and files
target ad19 (6210000::V6.21::ARMCLANG)
  device: STM32U575RGTx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x80FFFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: ad19 +hex
  AfterMake: hex2bin.bat ad19 ad19
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx
  c misc: -Wno-invalid-source-encoding
  c include: ../Core/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../Drivers/CMSIS/Include;..\Lepton\INC;..\Lepton\CONTROL\V3_5;..\Hardware;..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/User/Core
    ../Core/Src/: main.c icache.c memorymap.c stm32u5xx_it.c stm32u5xx_hal_msp.c
    ./: startup_stm32u575xx.s
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal_dcmi.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Application/LeptonSDK
    ../Lepton/SRC/: LEPTON_AGC.c LEPTON_CFG.c LEPTON_I2C_Protocol.c LEPTON_I2C_Service.c LEPTON_OEM.c LEPTON_RAD.c LEPTON_SDK.c LEPTON_SYS.c LEPTON_VID.c crc16fast.c
  group Application/LeptonAPP
    ../Lepton/CONTROL/V3_5/: Lepton_Common_Data.c Lepton_Stm32_Control.c Lepton_Stm32_I2C.c Lepton_Stm32_SPI_DMA.c Lepton_Delay.c
  group hardware
    ../Hardware/: bsp.c bsp.h i2c_cst816t.c i2c_cst816t.h st7789.c st7789.h st7789_def.h battery.c bsp_ov2640.c bsp_i2c.c
  group utilities
    ../Utilities/fonts/: fonts.c fonts.h
    ../Utilities/images/: colormap.h colormap_rgb565_msb.c COLOUR_ARCTIC.c COLOUR_BLACKHOT.c COLOUR_COLOUR1.c COLOUR_COLOUR2.c COLOUR_FUSION.c COLOUR_IRONBOW2.c COLOUR_RAINBOW.c images.c images.h
software components: CMSIS:CORE 4.3.0
